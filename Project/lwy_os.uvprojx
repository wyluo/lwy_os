# Keil uVision project lwy_os.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.2.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: lwy_os
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group include
    ../include/: FreeRTOSConfig.h FreeRTOS.h list.h portmacro.h
  group src
    ../src/: main.c list.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.1
